# Keil uVision project Basic.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Basic
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    C:/Users/Dong/Desktop/STMF4discover/STM32F4-Discovery_FW_V1.1.0/Project/Demonstration/: system_stm32f4xx.c
